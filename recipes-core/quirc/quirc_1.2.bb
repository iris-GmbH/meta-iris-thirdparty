# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

require recipes-core/quirc/quirc.inc

SRCREV = "542848dd6b9b0eaa9587bbf25b9bc67bd8a71fca"
