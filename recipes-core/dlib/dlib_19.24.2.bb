# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

require recipes-core/dlib/dlib.inc

SRCREV = "39749fba5163d4e25030358f6aa8d91617bfdca2"
