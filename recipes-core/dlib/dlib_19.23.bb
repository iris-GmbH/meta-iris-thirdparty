# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/dlib/dlib.inc

SRCREV = "074ab8bdbadbee1afb95653c3ce46867ed32dfa1"
