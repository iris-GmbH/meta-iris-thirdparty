# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/caf/caf.inc

SRCREV = "d25d4f998c4be627f39bb98f99dcfb3b88b9f877"
