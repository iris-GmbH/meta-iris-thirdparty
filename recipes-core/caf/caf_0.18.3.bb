# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require caf.inc

SRCREV = "728f6d82f451c037931e53701f8d8b9a900f36eb"

SRC_URI += "file://0001-Fix-CMakeLists.txt-for-installing-caf-tools.patch"
