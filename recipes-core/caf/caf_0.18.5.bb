# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/caf/caf.inc

SRCREV = "c2be26e7f9e3e84ef14730590fc4e7b25fb9d29a"
