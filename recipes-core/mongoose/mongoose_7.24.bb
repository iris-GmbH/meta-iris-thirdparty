# SPDX-License-Identifier: MIT
# Copyright (C) 2026 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "91b87a6bd8568f101680d4fc0db3d8773f74eb6c"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0ddcde673cf75f85dbdd2b3836c0d056"
