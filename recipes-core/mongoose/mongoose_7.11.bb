# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "5c8e05a4fc34c5309ceea887a7e60b895b2100d7"
LIC_FILES_CHKSUM = "file://LICENSE;md5=22bc55929d9472414a5640f30b54df43"

DEFAULT_PREFERENCE = "-1"
