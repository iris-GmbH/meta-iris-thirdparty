# SPDX-License-Identifier: MIT
# Copyright (C) 2026 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "02bdbb9ed6f0a8f7c42228c6e7cb35d748b60551"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0ddcde673cf75f85dbdd2b3836c0d056"
