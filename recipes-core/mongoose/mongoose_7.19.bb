# SPDX-License-Identifier: MIT
# Copyright (C) 2025 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "739d78a45a8fa6595498df67d11cac3e39af8c0e"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1652935c3807a36cf17125a4a217dbc2"

# Makefile was moved to test/Makefile with https://github.com/cesanta/mongoose/commit/89aaf1c30c20db939154121d4eb0320339b2f053
MAKEFILE_DIR="test"
