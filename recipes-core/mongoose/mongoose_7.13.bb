# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "52997c6c5170050148d23436d2ed398811f48c30"
LIC_FILES_CHKSUM = "file://LICENSE;md5=22bc55929d9472414a5640f30b54df43"
