# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "9d38e26b817b6b151fd925e9a8420a46c99a8375"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e177cce9e6b9dcdd6b666adec6a4a1e2"
