# SPDX-License-Identifier: MIT
# Copyright (C) 2024 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "6bb40e6ec96f95bfd36a816b430ea2726fac9d05"
LIC_FILES_CHKSUM = "file://LICENSE;md5=801edb9e029931905c8413f0ae9c406b"

# Makefile was moved to test/Makefile with https://github.com/cesanta/mongoose/commit/89aaf1c30c20db939154121d4eb0320339b2f053
MAKEFILE_DIR="test"
