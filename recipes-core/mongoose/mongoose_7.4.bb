# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "f08d2804292647f4c738ffaa4d9e4168114aa731"
LIC_FILES_CHKSUM = "file://LICENSE;md5=9cd42b5f2ca072e034ac9b6706aaffe7"

DEFAULT_PREFERENCE = "-1"
