# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "1b82aa02aa3d6fecfc23ed0a94c6917f139de1ad"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e177cce9e6b9dcdd6b666adec6a4a1e2"

DEFAULT_PREFERENCE = "-1"
