# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "b379816178abdcd59135aa32f990a4b3bbbfb54b"
LIC_FILES_CHKSUM = "file://LICENSE;md5=22bc55929d9472414a5640f30b54df43"
