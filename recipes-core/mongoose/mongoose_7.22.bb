# SPDX-License-Identifier: MIT
# Copyright (C) 2026 iris-GmbH infrared & intelligent sensors

require recipes-core/mongoose/mongoose.inc

SRCREV = "c288ac1f38424ffdd4d2fd5e1893fd4962642db3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0ddcde673cf75f85dbdd2b3836c0d056"
