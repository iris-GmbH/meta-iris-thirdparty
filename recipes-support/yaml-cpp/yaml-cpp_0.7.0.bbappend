FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}-${PV}:"

SRC_URI += "\
	file://0001-Fix-CMake-export-files-1077.patch \
"
