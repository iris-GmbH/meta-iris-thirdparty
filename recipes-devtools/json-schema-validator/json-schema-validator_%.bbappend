# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

SRC_URI += "file://0001-cmake-fix-install-path.patch"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
