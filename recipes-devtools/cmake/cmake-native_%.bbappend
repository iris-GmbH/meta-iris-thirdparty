FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cmake-Add-find-module-for-the-mongoose-library.patch"
